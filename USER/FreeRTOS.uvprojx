# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: FreeRTOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F407xx
  c misc: --diag_suppress=188,546,68,111
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;.;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\MALLOC;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\SRAM;..\LVGL;..\LVGL\src;..\LVGL\examples;..\LVGL\examples\porting;..\HARDWARE\TOUCH;..\TuyaSDK;.eide\deps;..\HARDWARE\PWM;..\HARDWARE\DHT11;..\HARDWARE\SGP30;..\HARDWARE\SHT30;..\HARDWARE\EXTI
  asm define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F407xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group TuyaSDK
    ../TuyaSDK/: mcu_api.c protocol.c system.c
  group TOUCH
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c myiic.c ott2001a.c touch.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: README.md
  group LVGL_PORT
    ../LVGL/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group LVGL_APP
    ../LVGL/lvgl_img/: bg_color.c Font18_Normal.c Font24_Normal.c Font30.c hpu_log.c switch_img.c
    ../LVGL/: my_gui.c
  group LVGL
    ../LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev_scroll.c lv_indev.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style_gen.c lv_obj_style.c lv_obj_tree.c lv_obj.c lv_refr.c lv_theme.c
    ../LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../LVGL/src/draw/gd32_ipa/: lv_gpu_gd32_ipa.c
    ../LVGL/src/draw/: lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_draw.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL/src/draw/nxp/: lv_gpu_nxp.c
    ../LVGL/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c
    ../LVGL/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_gpu_nxp_vglite.c
    ../LVGL/src/draw/sdl/: lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c lv_draw_sdl.c
    ../LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../LVGL/src/draw/sw/: lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c lv_draw_sw.c
    ../LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../LVGL/src/font/: lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12_subpx.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28_compressed.c lv_font_montserrat_28.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_font.c
    ../LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../LVGL/src/layouts/flex/: lv_flex.c
    ../LVGL/src/layouts/grid/: lv_grid.c
    ../LVGL/src/misc/: lv_anim_timeline.c lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_malloc_builtin.c lv_math.c lv_mem.c lv_memcpy_builtin.c lv_printf.c lv_style_gen.c lv_style.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt_ap.c lv_txt.c lv_utils.c
    ../LVGL/src/themes/basic/: lv_theme_basic.c
    ../LVGL/src/themes/default/: lv_theme_default.c
    ../LVGL/src/themes/mono/: lv_theme_mono.c
    ../LVGL/src/widgets/animimg/: lv_animimg.c
    ../LVGL/src/widgets/arc/: lv_arc.c
    ../LVGL/src/widgets/bar/: lv_bar.c
    ../LVGL/src/widgets/btn/: lv_btn.c
    ../LVGL/src/widgets/btnmatrix/: lv_btnmatrix.c
    ../LVGL/src/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    ../LVGL/src/widgets/canvas/: lv_canvas.c
    ../LVGL/src/widgets/chart/: lv_chart.c
    ../LVGL/src/widgets/checkbox/: lv_checkbox.c
    ../LVGL/src/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL/src/widgets/dropdown/: lv_dropdown.c
    ../LVGL/src/widgets/img/: lv_img.c
    ../LVGL/src/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL/src/widgets/keyboard/: lv_keyboard.c
    ../LVGL/src/widgets/label/: lv_label.c
    ../LVGL/src/widgets/led/: lv_led.c
    ../LVGL/src/widgets/line/: lv_line.c
    ../LVGL/src/widgets/list/: lv_list.c
    ../LVGL/src/widgets/menu/: lv_menu.c
    ../LVGL/src/widgets/meter/: lv_meter.c
    ../LVGL/src/widgets/msgbox/: lv_msgbox.c
    ../LVGL/src/widgets/objx_templ/: lv_objx_templ.c
    ../LVGL/src/widgets/roller/: lv_roller.c
    ../LVGL/src/widgets/slider/: lv_slider.c
    ../LVGL/src/widgets/span/: lv_span.c
    ../LVGL/src/widgets/spinbox/: lv_spinbox.c
    ../LVGL/src/widgets/spinner/: lv_spinner.c
    ../LVGL/src/widgets/switch/: lv_switch.c
    ../LVGL/src/widgets/table/: lv_table.c
    ../LVGL/src/widgets/tabview/: lv_tabview.c
    ../LVGL/src/widgets/textarea/: lv_textarea.c
    ../LVGL/src/widgets/tileview/: lv_tileview.c
    ../LVGL/src/widgets/win/: lv_win.c
  group HARDWARE
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/SGP30/: sgp30.c
    ../HARDWARE/SHT30/: SHT30.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/TIMER/: timer.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
